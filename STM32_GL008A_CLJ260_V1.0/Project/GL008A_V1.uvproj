# Keil uVision project GL008A_V1.uvproj, settings and files
target Myproject (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GL008A_V1 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\LIB\inc;..\startup;..\USER\inc;..\STemWinLibrary532\Config;..\STemWinLibrary532\inc;..\Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../USER/src/: main.c stm32f10x_it.c Setup.c 24cxx.c flash.c spi.c picture.c rtc.c ads8341.c printer.c ctiic.c lcd.c ft5206.c myiic.c serial.c crc16.c
  group lib
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_usart.c
  group cmsis
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group startup
    ../startup/: startup_stm32f10x_hd.s
